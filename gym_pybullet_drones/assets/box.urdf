Commit message: RRT collision checking

File: gym_pybullet_drones/assets/box.urdf (robot description, URDF)
Before this commit: robot test.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry visual box size=.5 .5 .5
